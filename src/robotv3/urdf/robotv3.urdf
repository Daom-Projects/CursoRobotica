Commit message: Con elementos del aula

File: src/robotv3/urdf/robotv3.urdf (robot description, URDF)
Before this commit: robot robotv3, 5 links, 4 joints
Joints:
- joint Lider_Join: origin xyz=0 -0.07775 0.2396 rpy=1.5708 0 1.5708 -> xyz=0 -0.07775 0.2396 rpy=0 0 -1.5708
